# Keil uVision project Fire_RT-Thread.uvprojx, settings and files
target Fire_RT-Thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_RT-Thread +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\bsp\usart;..\..\User\bsp\led;..\..\rtthread\3.0.3\components\finsh;..\..\rtthread\3.0.3\include;..\..\rtthread\3.0.3\include\libc;..\..\User\bsp\LCD;..\..\User\bsp\usart;..\..\User\bsp\usart3;..\..\User\bsp\delay;..\..\User\bsp\DHT11;..\..\User\bsp\sys;..\..\User;..\RVMDK（uv5）;..\..\User\my_task;..\..\User\bsp\MENU_KEY;..\..\User\bsp\MENU;..\..\User\bsp\key_matrix;..\..\FATFS\src;..\..\MALLOC;..\..\User\bsp\W25QXX;..\..\User\bsp\SDIO;..\..\User\bsp\SPI;..\..\FATFS\exfuns;..\..\User\bsp\RTC;..\..\User\bsp\usart2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group rtt/source
    ../../rtthread/3.0.3/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/ports
    ../../rtthread/3.0.3/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h board.c rtconfig.h
    ../../User/bsp/led/: bsp_led.c bsp_led.h
    ../../User/bsp/usart/: bsp_usart.c bsp_usart.h
    ../../User/bsp/usart2/: bsp_usart2.h bsp_usart2.c
    ../../User/bsp/usart3/: bsp_usart3.c
    ../../User/bsp/LCD/: bsp_lcd.c
    ../../User/bsp/delay/: delay.c
    ../../User/bsp/MENU_KEY/: MENU_KEY.c
    ../../User/bsp/DHT11/: bsp_dht11.c
    ../../User/bsp/sys/: sys.c
    ../../User/bsp/MENU/: Menu.c
    ../../User/bsp/SDIO/: sdio_sdcard.c
    ../../User/bsp/W25QXX/: w25qxx.c
    ../../User/bsp/SPI/: spi.c
    ../../User/bsp/RTC/: rtc.c
  group FATFS
    ../../FATFS/src/: diskio.c ff.c
    ../../FATFS/src/option/: cc936.c
    ../../FATFS/exfuns/: exfuns.c
  group MALLOC
    ../../MALLOC/: malloc.c
